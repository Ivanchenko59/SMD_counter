# Keil uVision project SMD_counter.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SMD_counter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\firmware;.\CMSIS\inc;.\code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group code
    ./code/src/: main.c utils.c fonts.c ssd1306.c ssd1306_i2c.c menu.c state_machine.c button.c
  group application
    ./CMSIS/inc/: core_cm3.h stm32f10x.h system_stm32f10x.h
    ./code/inc/: utils.h main.h fonts.h ssd1306.h ssd1306_i2c.h menu.h state_machine.h button.h
